## boards/shields/custom_keyboard/Kconfig.defconfig
```kconfig
if SHIELD_CUSTOM_KEYBOARD

config ZMK_KEYBOARD_NAME
    default "Custom ZMK KB"

endif
```
